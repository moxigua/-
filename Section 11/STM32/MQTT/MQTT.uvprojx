# Keil uVision project MQTT.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: W5500_TCP
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HAVE_CONFIG_H  WOLFSSL_USER_SETTINGS
  c include: .\ioLibrary_Driver-master\Ethernet;.\ioLibrary_Driver-master\Ethernet\W5500;.\ioLibrary_Driver-master\Application\loopback;.\ioLibrary_Driver-master\Internet;.\;.\ioLibrary_Driver-master\Internet\MQTT;.\ioLibrary_Driver-master\Internet\MQTT\MQTTPacket\src;.\wolfMQTT-master;.\MyAPPs;.\wolfmqtt-0.8
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c main_threads.c rtc.c stdout_USART.c
  group W5500_Driver
    ./ioLibrary_Driver-master/Ethernet/: socket.c wizchip_conf.c
    ./ioLibrary_Driver-master/Ethernet/W5500/: w5500.c
    ./ioLibrary_Driver-master/Internet/DHCP/: dhcp.c
    ./ioLibrary_Driver-master/Internet/MQTT/: mqtt_interface.c
    ./ioLibrary_Driver-master/Internet/DNS/: dns.c
  group W5500_Application
    ./: W5500_functions.c W5500_MQTT_Functions.c
  group wolfSSL_config
    ./: config.h
  group WolfMQTT
    ./wolfMQTT-0.8/src/: mqtt_client.c mqtt_packet.c mqtt_socket.c mqttnet.c
  group MyAPP
    ./MyAPPs/Output/: ka.c led.c
    ./MyAPPs/Button/: Buttons.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:SPI 2.2, CMSIS Driver:USART 2.3, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, wolfSSL:wolfCrypt:CORE 4.4.0, wolfSSL:wolfSSL:Core 4.4.0
