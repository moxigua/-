# Keil uVision project W5500_HTTP API.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: W5500_TCP
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HAVE_CONFIG_H  WOLFSSL_USER_SETTINGS  ENABLE_MQTT_TLS
  c include: .\ioLibrary_Driver-master\Ethernet;.\ioLibrary_Driver-master\Ethernet\W5500;.\ioLibrary_Driver-master\Application\loopback;.\ioLibrary_Driver-master\Internet;.\;.\MyAPPs;.\wolfssl-conf;.\wolfssl-3.10.2;.\wolfssl-3.10.2\IDE\MDK5-ARM\Conf;.\wolfssl-3.10.2\IDE\MDK5-ARM\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c stdout_USART.c main_threads.c
    ./ioLibrary_Driver-master/Application/loopback/: loopback.c
    ./MyAPPs/RTC/: rtc.c
  group W5500_Driver
    ./ioLibrary_Driver-master/Ethernet/: socket.c wizchip_conf.c
    ./ioLibrary_Driver-master/Ethernet/W5500/: w5500.c
    ./ioLibrary_Driver-master/Internet/DHCP/: dhcp.c
    ./ioLibrary_Driver-master/Internet/DNS/: dns.c
    ./ioLibrary_Driver-master/Internet/SNTP/: sntp.c
  group W5500_Application
    ./: http.c W5500_functions.c
  group myApps
    ./MyAPPs/Output/: led.c ka.c
    ./MyAPPs/Button/: Buttons.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, CMSIS Driver:SPI 2.2, CMSIS Driver:USART 2.2, Compiler:I/O:STDOUT 1.1.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0
